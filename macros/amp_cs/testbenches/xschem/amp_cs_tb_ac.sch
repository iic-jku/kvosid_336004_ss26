** sch_path: macros/amp_cs/testbenches/xschem/amp_cs_tb_ac.sch
**.subckt amp_cs_tb_ac
VDD VDD GND {VDD}
vin vin GND dc {Vcm} ac 1
C1 vout GND {cload} m=1
xamp1 VDD vin vout GND amp_cs
**** begin user architecture code


**nr_workers=50
**sort_results_index=0
**results_plot_contour_index=
**results_plot_logx_index=
**results_plot_logy_index=

**parameter_sweep_begin
**w_m1=Auto:1u:10:10u
**rload_cs=Auto:3k:5:10k
**parameter_sweep_end

**results_plot_begin
**vout
**id
**gm
**results_plot_end




.param VDD=1.5
.param Vcm=VDD/2
.temp 27
.param cload=10p
.param Rload=1k
.param w_m1=20u
.param l_m1=0.5u
.param rload_cs=3.4k
.options savecurrents klu method=gear reltol=1e-4 abstol=1e-15 gmin=1e-15
.control

save all


* Operating Point Analysis
op
let vout = v(vout)
let id  = @n.xamp1.xm1.nsg13_lv_pmos[ids]
let gm  = @n.xamp1.xm1.nsg13_lv_pmos[gm]

echo results_sweep_begin
print vout
print id
print gm
echo results_sweep_end


remzerovec
write @schname\.raw

*quit
.endc



.include [file rootname [file tail [xschem get schname]]].save




.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt



**** end user architecture code
**.ends

* expanding   symbol:  amp_cs.sym # of pins=4
** sym_path: macros/amp_cs/schematic/xschem/amp_cs.sym
** sch_path: macros/amp_cs/schematic/xschem/amp_cs.sch
.subckt amp_cs vdd vin vout vss
*.ipin vin
*.opin vout
*.iopin vdd
*.iopin vss
XM1 vout vin vdd vdd sg13_lv_pmos w={w_m1} l={l_m1} ng=1 m=1 mm_ok=1
R2 vout vss {rload_cs} m=1
.ends

.GLOBAL GND
.GLOBAL VDD
.end
