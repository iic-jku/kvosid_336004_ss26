** sch_path: macros/lna_inv/verification/cace/templates/lna_inv_tb_cace.sch
**.subckt lna_inv_tb_cace
vin1 vsrc GND dc 0 ac 1
rs vsrc vin 50 m=1
x1 vin vout VDD GND lna_inv
rl vout GND 200 noisy=0 m=1
vsup VDD GND CACE{vdd}
**** begin user architecture code


.include CACE{DUT_path}
.temp CACE{temp}
.param WN=CACE{WN} LNCH=CACE{LNCH} NGN=CACE{NGN} WP=CACE{WP} LPCH=CACE{LPCH} NGP=CACE{NGP}
.param RF=CACE{RF} CPAD=CACE{CPAD} LSH=CACE{LSH} RLSH=CACE{RLSH} CD=CACE{CD}
.param CC=CACE{CC} CBLK=CACE{CBLK}
.param RFMODE=1
.options savecurrents reltol=1e-4 abstol=1e-15 gmin=1e-15
* no klu: ngspice-47 refuses a noise analysis under it
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.control

save all

* Operating point: supply current. Base units throughout, CACE scales by the datasheet unit
op
let idd_a = -vsup#branch

* Input impedance from the source's branch current (the resistor's ac current is not saved), transconductance at the load
ac lin 201 2.0G 3.0G
let iin = -vin1#branch
let zin = v(vin)/iin
let s11mag = db((zin-50)/(zin+50))
meas ac s11_db find s11mag at=2.44G
let vom = mag(v(vout))
meas ac vo find vom at=2.44G
let gm_s = vo/200/0.5

* Noise figure at the band centre: input-referred noise against the source's own 4kT*50
noise v(vout) vin1 lin 1 2.44G 2.44G
setplot noise1
let tk = CACE{temp} + 273.15
* inoise_spectrum is an amplitude density, V per root Hz, hence the square
let nf_db = 10*log10(inoise_spectrum[0]^2/(4*1.380649e-23*tk*50))
let idd_out = op1.idd_a
let s11_out = ac1.s11_db
let gm_out = ac1.gm_s

echo $&idd_out $&s11_out $&gm_out $&nf_db > CACE{simpath}/CACE{filename}_CACE{N}.data

.endc



.lib cornerMOSlv.lib mos_CACE{corner_mos}
.lib cornerRES.lib res_CACE{corner_r}
.lib cornerCAP.lib cap_typ

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
