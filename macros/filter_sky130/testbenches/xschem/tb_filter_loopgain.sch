** sch_path: macros/filter_sky130/testbenches/xschem/tb_filter_loopgain.sch
**.subckt tb_filter_loopgain
VIN vid GND 0 AC 1
E4 vout1 GND voutp1 voutn1 1
VIINP vip vipp 0
VIINN vin vinn 0
R1 net1 net3 650k m=1
R2 voutn1 net3 1.3Meg m=1
R3 net3 vr_n 100k m=1
C1 voutn1 vr_n 1p m=1
C3 net3 net2 10p m=1
R11 net1 net2 650k m=1
R21 net2 voutp1 1.3Meg m=1
R31 net2 vr_p 100k m=1
C5 vr_p voutp1 1p m=1
E5 vout GND voutp2 voutn2 1
VIOP vo_opa_n voutn1 0
VION vo_opa_p voutp1 0
E6 vr GND vr_p vr_n 1
C7 vi_opa_n vinn 1G m=1
C8 vipp vi_opa_p 1G m=1
L25 vi_opa_n vr_p 1G m=1
L28 vi_opa_p vr_n 1G m=1
xamp1 VDD vi_opa_n vi_opa_p vo_opa_p di_pon vo_opa_n GND amp
V3 VDD GND 1.8
V4 di_pon GND 1.8
C4 voutp2 voutn2 1p m=1
R5 voutp1 voutp2 800k m=1
R6 voutn1 voutn2 800k m=1
x2 vip vid vcmi GND vin single2dm
V2 vcmi GND 0.9
**** begin user architecture code


.options savecurrents
.options method=gear reltol=.01
.options sparse
.control
save all

let f_sig = 100
let f_min = 10
let f_max = 100G
let f_stop = 5Meg
let tper_sig = 1/f_sig
let tfr_sig = tper_sig/2
let Adc = 10
let beta = 1/Adc
let v_step_o = 0.9
let v_step_i = v_step_o/Adc

let t_rf = 0.1u
let t_step = 50u
let t_delay = 0
let t_per = 2*t_step

let tstep = 0.1*t_rf
let tstop = 2*t_per
let tstart = t_delay

*alter @VIN[SIN] = [ 0 0.01 $&f_sig 0 0 0 ]
alter @VIN[DC] = 0.0

set wr_singlescale
set wr_vecnames
option numdgt=3


** Main Simulations
	op
	ac dec 100 $&const.f_min $&const.f_max

	setplot ac1
	let A1 = v(vout1)/v(vid)
	let A2 = v(vout)/v(vid)
	let L = v(vr)/v(vid)
	let A = L/beta

	let L_re = real(L)
	let L_im = imag(L)

	let L_dB = vdb(L)
	let L_arg = 180/PI*cphase(L)
	let A_dB = vdb(A)
	let A_arg = 180/PI*cphase(A)

	let fdc = const.f_min+1

	meas ac fug find frequency when L_dB=0
	meas ac pm find L_arg when frequency=fug

	let pm = 180-abs(pm)

	print pm

	let err_gain = 1-10^(Adc/20)/10
	let Adc_ol_min = (1-err_gain)/err_gain

	print err_gain
	print Adc_ol_min

	plot L_dB L_arg A_dB A_arg title 'Bode Plot of Loop Gain' ylabel 'Magnitude (dB) / Phase (Deg)'
	plot L_im vs L_re retraceplot title 'Nyquist Plot of Loop Gain' ylabel 'Imaginary Part' xlabel 'Real Part'


alter @VIN[DC] = 0
op

remzerovec
write tb_filter_loopgain.raw
.endc


.include [file rootname [file tail [xschem get schname]]].save


** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
